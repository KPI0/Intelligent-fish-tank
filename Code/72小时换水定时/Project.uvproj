# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h Timer0.c Timer0.h
    E:/Download/5、基于51单片机——步进电机控制实验/5、基于51单片机——步进电机控制实验/: delaytime10us.c delaytime10us.h MotorRun.c MotorRun.h
    ../13-1 DS18B20温度读取/: DS18B20.c DS18B20.h OneWire.c OneWire.h
